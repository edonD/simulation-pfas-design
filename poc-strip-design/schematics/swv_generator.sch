v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 10 -100 10 -70 { lab=#net1}
N 10 -130 40 -130 { lab=VDD}
N 40 -160 40 -130 { lab=VDD}
N 10 -160 40 -160 { lab=VDD}
N 10 -40 40 -40 { lab=VSS}
N 40 -40 40 0 { lab=VSS}
N 10 0 40 0 { lab=VSS}
N 10 -10 10 0 { lab=VSS}
N 10 -40 10 -30 { lab=VSS}
N 10 -190 10 -160 { lab=VDD}
N 10 -160 10 -130 { lab=VDD}
N 10 -220 10 -190 { lab=VDD}
N 10 -220 20 -220 { lab=VDD}
N 10 -20 10 0 { lab=VSS}
N 10 -70 10 -40 { lab=#net1}
N 10 -130 10 -100 { lab=#net1}
N 10 -220 10 -190 { lab=VDD}
N 10 -160 10 -130 { lab=VDD}
N 10 -100 10 -70 { lab=#net1}
N 10 -40 10 -10 { lab=VSS}
N 10 0 10 20 { lab=VSS}
N 10 20 20 20 { lab=VSS}
N 10 10 10 20 { lab=VSS}
N 10 -10 10 0 { lab=VSS}
N 10 -190 10 -160 { lab=VDD}
N 10 -160 10 -130 { lab=VDD}
N 10 -130 10 -100 { lab=#net1}
N 10 -70 10 -40 { lab=#net1}
N 10 -40 10 -10 { lab=VSS}
N 10 0 20 0 { lab=VSS}
N 10 10 20 10 { lab=VSS}
N 10 20 10 50 { lab=VSS}
N 10 50 20 50 { lab=VSS}
N 10 40 10 50 { lab=VSS}
N 10 -220 20 -220 { lab=VDD}
N 10 -220 10 -190 { lab=VDD}
N 10 -190 20 -190 { lab=VDD}
N 10 -160 20 -160 { lab=VDD}
N 10 -130 20 -130 { lab=VDD}
N 10 -100 20 -100 { lab=VDD}
N 10 -70 20 -70 { lab=VDD}
N 10 -40 20 -40 { lab=VDD}
N 10 -10 20 -10 { lab=VSS}
N 10 0 10 10 { lab=VSS}
N 10 50 10 80 { lab=VSS}
N 10 80 20 80 { lab=VSS}
N 10 70 10 80 { lab=VSS}
N 10 20 10 40 { lab=VSS}
N 10 -10 10 0 { lab=VSS}
N 10 -40 10 -30 { lab=VSS}
N 10 -160 10 -130 { lab=VDD}
N 10 -190 10 -160 { lab=VDD}
N 10 -220 10 -190 { lab=VDD}
N 10 -130 10 -100 { lab=#net1}
N 10 -70 10 -40 { lab=#net1}
N 10 -40 10 -30 { lab=VSS}
N 10 0 10 10 { lab=VSS}
N 10 40 10 50 { lab=VSS}
N 10 70 10 80 { lab=VSS}
N 10 10 20 10 { lab=VSS}
N 10 50 20 50 { lab=VSS}
N 10 80 20 80 { lab=VSS}
N 10 -10 20 -10 { lab=VSS}
N 10 -70 20 -70 { lab=VDD}
N 10 -40 20 -40 { lab=VDD}
N 10 -160 20 -160 { lab=VDD}
N 10 -190 20 -190 { lab=VDD}
N 10 -220 20 -220 { lab=VDD}
N 10 -100 20 -100 { lab=VDD}
N 10 -130 20 -130 { lab=VDD}
N 10 10 10 40 { lab=VSS}
N 10 -220 10 -190 { lab=VDD}
N 10 -190 10 -160 { lab=VDD}
N 10 -160 10 -130 { lab=VDD}
N 10 -130 10 -100 { lab=#net1}
N 10 -70 10 -40 { lab=#net1}
N 10 -40 10 -30 { lab=VSS}
N 10 0 10 10 { lab=VSS}
N 10 40 10 50 { lab=VSS}
N 10 70 10 80 { lab=VSS}
N 10 10 20 10 { lab=VSS}
N 10 50 20 50 { lab=VSS}
N 10 80 20 80 { lab=VSS}
N 10 -10 20 -10 { lab=VSS}
N 10 -70 20 -70 { lab=VDD}
N 10 -40 20 -40 { lab=VDD}
N 10 -160 20 -160 { lab=VDD}
N 10 -190 20 -190 { lab=VDD}
N 10 -220 20 -220 { lab=VDD}
N 10 -100 20 -100 { lab=VDD}
N 10 -130 20 -130 { lab=VDD}
N 10 10 10 40 { lab=VSS}
N 10 -220 10 -190 { lab=VDD}
N 10 -190 10 -160 { lab=VDD}
N 10 -160 10 -130 { lab=VDD}
N 10 -130 10 -100 { lab=#net1}
N 10 -70 10 -40 { lab=#net1}
N 10 -40 10 -30 { lab=VSS}
N 10 0 10 10 { lab=VSS}
N 10 40 10 50 { lab=VSS}
N 10 70 10 80 { lab=VSS}
N 10 10 20 10 { lab=VSS}
N 10 50 20 50 { lab=VSS}
N 10 80 20 80 { lab=VSS}
N 10 -10 20 -10 { lab=VSS}
N 10 -70 20 -70 { lab=VDD}
N 10 -40 20 -40 { lab=VDD}
N 10 -160 20 -160 { lab=VDD}
N 10 -190 20 -190 { lab=VDD}
N 10 -220 20 -220 { lab=VDD}
N 10 -100 20 -100 { lab=VDD}
N 10 -130 20 -130 { lab=VDD}
N 10 10 10 40 { lab=VSS}
N 10 -220 10 -190 { lab=VDD}
N 10 -190 10 -160 { lab=VDD}
N 10 -160 10 -130 { lab=VDD}
N 10 -130 10 -100 { lab=#net1}
N 10 -70 10 -40 { lab=#net1}
N 10 -40 10 -30 { lab=VSS}
N 10 0 10 10 { lab=VSS}
N 10 40 10 50 { lab=VSS}
N 10 70 10 80 { lab=VSS}
N 10 10 20 10 { lab=VSS}
N 10 50 20 50 { lab=VSS}
N 10 80 20 80 { lab=VSS}
N 10 -10 20 -10 { lab=VSS}
N 10 -70 20 -70 { lab=VDD}
N 10 -40 20 -40 { lab=VDD}
N 10 -160 20 -160 { lab=VDD}
N 10 -190 20 -190 { lab=VDD}
N 10 -220 20 -220 { lab=VDD}
N 10 -100 20 -100 { lab=VDD}
N 10 -130 20 -130 { lab=VDD}
N 10 10 10 40 { lab=VSS}
N 10 -220 10 -190 { lab=VDD}
N 10 -190 10 -160 { lab=VDD}
N 10 -160 10 -130 { lab=VDD}
N 10 -130 10 -100 { lab=#net1}
N 10 -70 10 -40 { lab=#net1}
N 10 -40 10 -30 { lab=VSS}
N 10 0 10 10 { lab=VSS}
N 10 40 10 50 { lab=VSS}
N 10 70 10 80 { lab=VSS}
N 10 10 20 10 { lab=VSS}
N 10 50 20 50 { lab=VSS}
N 10 80 20 80 { lab=VSS}
N 10 -10 20 -10 { lab=VSS}
N 10 -70 20 -70 { lab=VDD}
N 10 -40 20 -40 { lab=VDD}
N 10 -160 20 -160 { lab=VDD}
N 10 -190 20 -190 { lab=VDD}
N 10 -220 20 -220 { lab=VDD}
N 10 -100 20 -100 { lab=VDD}
N 10 -130 20 -130 { lab=VDD}
N 10 10 10 40 { lab=VSS}
N 10 -220 10 -190 { lab=VDD}
N 10 -190 10 -160 { lab=VDD}
N 10 -160 10 -130 { lab=VDD}
N 10 -130 10 -100 { lab=#net1}
N 10 -70 10 -40 { lab=#net1}
N 10 -40 10 -30 { lab=VSS}
N 10 0 10 10 { lab=VSS}
N 10 40 10 50 { lab=VSS}
N 10 70 10 80 { lab=VSS}
N 10 10 20 10 { lab=VSS}
N 10 50 20 50 { lab=VSS}
N 10 80 20 80 { lab=VSS}
N 10 -10 20 -10 { lab=VSS}
N 10 -70 20 -70 { lab=VDD}
N 10 -40 20 -40 { lab=VDD}
N 10 -160 20 -160 { lab=VDD}
N 10 -190 20 -190 { lab=VDD}
N 10 -220 20 -220 { lab=VDD}
N 10 -100 20 -100 { lab=VDD}
N 10 -130 20 -130 { lab=VDD}
N 10 10 10 40 { lab=VSS}
N 10 -220 10 -190 { lab=VDD}
N 10 -190 10 -160 { lab=VDD}
N 10 -160 10 -130 { lab=VDD}
N 10 -130 10 -100 { lab=#net1}
N 10 -70 10 -40 { lab=#net1}
N 10 -40 10 -30 { lab=VSS}
N 10 0 10 10 { lab=VSS}
N 10 40 10 50 { lab=VSS}
N 10 70 10 80 { lab=VSS}
N 10 10 20 10 { lab=VSS}
N 10 50 20 50 { lab=VSS}
N 10 80 20 80 { lab=VSS}
N 10 -10 20 -10 { lab=VSS}
N 10 -70 20 -70 { lab=VDD}
N 10 -40 20 -40 { lab=VDD}
N 10 -160 20 -160 { lab=VDD}
N 10 -190 20 -190 { lab=VDD}
N 10 -220 20 -220 { lab=VDD}
N 10 -100 20 -100 { lab=VDD}
N 10 -130 20 -130 {