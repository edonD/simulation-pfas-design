v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 70 -100 70 -60 { lab=#net1}
N 70 -10 70 40 { lab=Vref}
N 70 40 100 40 { lab=Vref}
N 70 10 120 10 { lab=VSS}
N 120 10 120 40 { lab=VSS}
N 70 -130 120 -130 { lab=VDD}
N 120 -130 120 -100 { lab=VDD}
N 70 -180 70 -160 { lab=VDD}
N 240 -130 240 -100 { lab=VDD}
N 240 -10 240 20 { lab=VSS}
N 180 -40 200 -40 { lab=#net1}
N 240 -180 240 -160 { lab=VDD}
N 240 50 240 80 { lab=VSS}
N 240 -40 290 -40 { lab=VDD}
N 290 -70 290 -40 { lab=VDD}
N 240 -70 290 -70 { lab=VDD}
N 240 20 240 50 { lab=VSS}
N 240 -10 270 -10 { lab=VSS}
N 270 -10 270 20 { lab=VSS}
N 240 20 270 20 { lab=VSS}
N 240 -160 240 -130 { lab=VDD}
N 70 -160 70 -130 { lab=VDD}
N 70 -60 70 -50 { lab=#net1}
N 70 -50 180 -50 { lab=#net1}
N 180 -50 180 -40 { lab=#net1}
N 240 -130 240 -100 { lab=VDD}
N 240 -70 240 -40 { lab=VDD}
N 240 80 240 110 { lab=VSS}
N 240 50 240 80 { lab=VSS}
N 240 110 240 140 { lab=VSS}
N 240 140 240 170 { lab=VSS}
N 240 170 240 200 { lab=VSS}
N 240 140 270 140 { lab=VSS}
N 270 110 270 140 { lab=VSS}
N 240 110 270 110 { lab=VSS}
N 240 170 270 170 { lab=VSS}
N 270 140 270 170 { lab=VSS}
N 240 200 240 230 { lab=VSS}
N 240 230 240 260 { lab=VSS}
N 240 260 240 290 { lab=VSS}
N 240 290 240 320 { lab=VSS}
N 240 320 240 350 { lab=VSS}
N 240 260 270 260 { lab=VSS}
N 270 230 270 260 { lab=VSS}
N 240 230 270 230 { lab=VSS}
N 240 290 270 290 { lab=VSS}
N 270 260 270 290 { lab=VSS}
N 240 350 240 380 { lab=VSS}
N 240 380 240 410 { lab=VSS}
N 240 410 240 440 { lab=VSS}
N 240 440 240 470 { lab=VSS}
N 240 470 240 500 { lab=VSS}
N 240 410 270 410 { lab=VSS}
N 270 380 270 410 { lab=VSS}
N 240 380 270 380 { lab=VSS}
N 240 440 270 440 { lab=VSS}
N 270 410 270 440 { lab=VSS}
N 240 500 240 530 { lab=VSS}
N 240 530 240 560 { lab=VSS}
N 240 560 240 590 { lab=VSS}
N 240 590 240 620 { lab=VSS}
N 240 620 240 650 { lab=VSS}
N 240 590 270 590 { lab=VSS}
N 270 560 270 590 { lab=VSS}
N 240 560 270 560 { lab=VSS}
N 240 650 240 680 { lab=VSS}
N 240 680 240 710 { lab=VSS}
N 240 710 240 740 { lab=VSS}
N 240 740 240 770 { lab=VSS}
N 240 770 240 800 { lab=VSS}
N 240 740 270 740 { lab=VSS}
N 270 710 270 740 { lab=VSS}
N 240 710 270 710 { lab=VSS}
N 240 800 240 830 { lab=VSS}
N 240 830 240 860 { lab=VSS}
N 240 860 240 890 { lab=VSS}
N 240 890 240 920 { lab=VSS}
N 240 920 240 950 { lab=VSS}
N 240 890 270 890 { lab=VSS}
N 270 860 270 890 { lab=VSS}
N 240 860 270 860 { lab=VSS}
N 240 950 240 980 { lab=VSS}
N 240 980 240 1010 { lab=VSS}
N 240 1010 240 1040 { lab=VSS}
N 240 1040 240 1070 { lab=VSS}
N 240 1070 240 1100 { lab=VSS}
N 240 1040 270 1040 { lab=VSS}
N 270 1010 270 1040 { lab=VSS}
N 240 1010 270 1010 { lab=VSS}
N 240 1100 240 1130 { lab=VSS}
N 240 1130 240 1160 { lab=VSS}
N 240 1160 240 1190 { lab=VSS}
N 240 1190 240 1220 { lab=VSS}
N 240 1220 240 1250 { lab=VSS}
N 240 1190 270 1190 { lab=VSS}
N 270 1160 270 1190 { lab=VSS}
N 240 1160 270 1160 { lab=VSS}
N 240 1250 240 1280 { lab=VSS}
N 240 1280 240 1310 { lab=VSS}
N 240 1310 240 1340 { lab=VSS}
N 240 1340 240 1370 { lab=VSS}
N 240 1370 240 1400 { lab=VSS}
N 240 1340 270 1340 { lab=VSS}
N 270 1310 270 1340 { lab=VSS}
N 240 1310 270 1310 { lab=VSS}
N 240 1400 240 1430 { lab=VSS}
N 240 1430 240 1460 { lab=VSS}
N 240 1460 240 1490 { lab=VSS}
N 240 1490 240 1520 { lab=VSS}
N 240 1520 240 1550 { lab=VSS}
N 240 1490 270 1490 { lab=VSS}
N 270 1460 270 1490 { lab=VSS}
N 240 1460 270 1460 { lab=VSS}
N 240 1550 240 1580 { lab=VSS}
N 240 1580 240 1610 { lab=VSS}
N 240 1610 240 1640 { lab=VSS}
N 240 1640 240 1670 { lab=VSS}
N 240 1670 240 1700 { lab=VSS}
N 240 1640 270 1640 { lab=VSS}
N 270 1610 270 1640 { lab=VSS}
N 240 1610 270 1610 { lab=VSS}
N 240 1700 240 1730 { lab=VSS}
N 240 1730 240 1760 { lab=VSS}
N 240 1760 240 1790 { lab=VSS}
N 240 1790 240 1820 { lab=VSS}
N 240 1820 240 1850 { lab=VSS}
N 240 1790 270 1790 { lab=VSS}
N 270 1760 270 1790 { lab=VSS}
N 240 1760 270 1760 { lab=VSS}
N 240 1850 240 1880 { lab=VSS}
N 240 1880 240 1910 { lab=VSS}
N 240 1910 240 1940 { lab=VSS}
N 240 1940 240 1970 { lab=VSS}
N 240 1970 240 2000 { lab=VSS}
N 240 1940 270 1940 { lab=VSS}
N 270 1910 270 1940 { lab=VSS}
N 240 1910 270 1910 { lab=VSS}
N 240 2000 240 2030 { lab=VSS}
N 240 2030 240 2060 { lab=VSS}
N 240 2060 240 2090 { lab=VSS}
N 240 2090 240 2120 { lab=VSS}
N 240 2120 240 2150 { lab=VSS}
N 240 2090 270 2090 { lab=VSS}
N 270 2060 270 2090 { lab=VSS}
N 240 2060 270 2060 { lab=VSS}
N 240 2150 240 2180 { lab=VSS}
N 240 2180 240 2210 { lab=VSS}
N 240 2210 240 2240 { lab=VSS}
N 240 2240 240 2270 { lab=VSS}
N 240 2270 240 2300 { lab=VSS}
N 240 2240 270 2240 { lab=VSS}
N 270 2210 270 2240 { lab=VSS}
N 240 2210 270 2210 { lab=VSS}
N 240 2300 240 2330 { lab=VSS}
N 240 2330 240 2360 { lab=VSS}
N 240 2360 240 2390 { lab=VSS}
N 240 2390 240 2420 { lab=VSS}
N 240 2420 240 2450 { lab=VSS}
N 240 2390 270 2390 { lab=VSS}
N 270 2360 270 2390 { lab=VSS}
N 240 2360 270 2360 { lab=VSS}
N 240 2450 240 2480 { lab=VSS}
N 240 2480 240 2510 { lab=VSS}
N 240 2510 240 2540 { lab=VSS}
N 240 2540 240 25